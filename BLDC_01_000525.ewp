# IAR project BLDC_01_000525.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F405VG ST STM32F405VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F40XX
  ICCARM.CCIncludePath2: board; app; Libraries\CMSIS\Device\ST\STM32F4xx\Include; Libraries\STM32F4xx_StdPeriph_Driver\inc; modules\Header
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SVC23M_S2303.hex
  ILINK.IlinkOutputFile: SVC2_3.out
  ILINK.IlinkIcfFile: config\stm32f4xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  OBJCOPY.OOCOutputFile: SVC_IAR_930327.hex
  ILINK.IlinkOutputFile: SVC_IAR_930327.out
  group 1_ StartUp
    startup/: startup_stm32f40xx.s system_stm32f4xx.c
  group 2_ Main
    modules/Source/: Init_2.c ISR_2.c main.c
    app/: stm32f4xx_it.c
  group 3_ Peripherals/3_1_ General
    modules/Source/: A2D_2.c Flow_EXH_Sensirion.c Pressure_INHEXH_HoneyWell_1.c Timer_1.c Usart_3.c
    ../../../code/VT40-VH64VA40(V64R61)standby-newmerge 6-18/SVC/Source/SVC28/CPU2(SVC)/modules/Header/: stm32f4xx_dma.h
  group 4_ Algorithm
    modules/Source/: Algorithm.c
  group 5_ STM32F4xx_StdPeriph_Driver
    Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
